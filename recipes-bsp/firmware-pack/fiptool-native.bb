LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

require fiptool-native.inc

OPENEULER_LOCAL_NAME = "fiptool"
SRC_URI = " \
    file://fiptool \
"

PV = "2.6"
PR = "r1"
